# Keil uVision project FreeRTOS_Fresh_Air_v1_1.uvprojx, settings and files
target FreeRTOS_Fresh_Air_v1_1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F105R8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FreeRTOS_Fresh_Air_v1_1 +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\FreeRTOS_Fresh_Air_v1_1;.\CMSIS\inc;..\SOURCE\inc;..\FreeRTOS\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS
    ./CMSIS/src/: core_cm3.c system_stm32f10x.c
  group StartUp
    ./CMSIS/StartUp/: startup_stm32f10x_cl.s
  group FreeRTOS
    ../FreeRTOS/src/: croutine.c event_groups.c list.c port.c queue.c stream_buffer.c tasks.c timers.c heap_4.c
  group Source
    ../SOURCE/src/: main.c setting.c Ee24cxx.c rtc.c w25qxx.c can.c rs485.c nrf24.c
